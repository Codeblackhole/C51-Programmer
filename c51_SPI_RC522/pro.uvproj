# Keil uVision project pro.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: pro +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\c51;.\RC522
  group USER
    ./: pro.c
  group RC522
    ./RC522/: rc522.c
